# IAR project cm7_0.ewp, settings and files
configuration rev_b (ARM, debug)
  General.OGChipSelectEditMenu: CYT4BF_M7 Infineon CYT4BF_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: tviibh8m; CYT4BF8CDE; CY_USE_PSVP=0; CY_MCU_rev_b; CY_CORE_CM7_0; __ICACHE_PRESENT=1; __DCACHE_PRESENT=1
  ICCARM.CCIncludePath2: ..\..\..\..\..\common\hdr; ..\..\..\..\..\common\hdr\cmsis\include; ..\..\..\..\..\common\src\drivers; ..\..\..\..\..\common\src\mw; ..\..\..\..\hdr\rev_b; ..\..\..\..\hdr\rev_b\ip; ..\..\..\..\hdr\rev_b\mcureg; ..\..\..\..\src; ..\..\..\..\src\interrupts\rev_b; ..\..\..\..\src\drivers; ..\..\..\..\src\system\rev_b
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cm7_0.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkConfigDefines: _CORE_$PROJ_FNAME$_=0; _LINK_$LINK_LOCATION$_=0
  ILINK.IlinkIcfFile: ..\..\linker_directives_tviibh.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\src\drivers\crypto\libs\libcrypto_client_cm7_0_iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration rev_c (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: tviibh8m; CYT4BF8CDE; CY_USE_PSVP=0; CY_MCU_rev_c; CY_CORE_CM7_0; __ICACHE_PRESENT=1; __DCACHE_PRESENT=1
  ICCARM.CCIncludePath2: ..\..\..\..\..\common\hdr; ..\..\..\..\..\common\hdr\cmsis\include; ..\..\..\..\..\common\src\drivers; ..\..\..\..\..\common\src\mw; ..\..\..\..\hdr\rev_c; ..\..\..\..\hdr\rev_c\ip; ..\..\..\..\hdr\rev_c\mcureg; ..\..\..\..\src; ..\..\..\..\src\interrupts\rev_c; ..\..\..\..\src\drivers; ..\..\..\..\src\system\rev_c
  ILINK.IlinkIcfFile: ..\..\linker_directives_tviibh_rev_c.icf
configuration rev_d (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: tviibh8m; CYT4BFCCHE; CY_USE_PSVP=0; CY_MCU_rev_d; CY_CORE_CM7_0; __ICACHE_PRESENT=1; __DCACHE_PRESENT=1
  ICCARM.CCIncludePath2: ..\..\..\..\..\common\hdr; ..\..\..\..\..\common\hdr\cmsis\include; ..\..\..\..\..\common\src\drivers; ..\..\..\..\..\common\src\mw; ..\..\..\..\hdr\rev_d; ..\..\..\..\hdr\rev_d\ip; ..\..\..\..\hdr\rev_d\mcureg; ..\..\..\..\src; ..\..\..\..\src\interrupts\rev_d; ..\..\..\..\src\drivers; ..\..\..\..\src\system\rev_d
  ILINK.IlinkIcfFile: ..\..\linker_directives_tviibh_rev_c.icf
configuration rtos (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: tviibh8m; CYT4BF8CDE; CY_USE_PSVP=0; CY_MCU_rev_d; CY_CORE_CM7_0; __ICACHE_PRESENT=1; __DCACHE_PRESENT=1
  ICCARM.CCIncludePath2: ..\..\..\..\..\common\hdr; ..\..\..\..\..\common\hdr\cmsis\include; ..\..\..\..\..\common\src\drivers; ..\..\..\..\..\common\src\mw; ..\..\..\..\..\common\src\rtos\include; ..\..\..\..\..\common\src\rtos\portable\IAR\ARM_CM7\r0p1; ..\..\..\..\hdr\rev_d; ..\..\..\..\hdr\rev_d\ip; ..\..\..\..\hdr\rev_d\mcureg; ..\..\..\..\src; ..\..\..\..\src\interrupts\rev_d; ..\..\..\..\src\drivers; ..\..\..\..\src\system\rev_d
  AARM.AUserIncludes: ..\..\..\..\..\common\src\rtos\include
  ILINK.IlinkIcfFile: ..\..\linker_directives_tviibh_rev_c.icf
  group hdr
    ../../../../../common/hdr/: cy_project.h
  group hdr/cmsis/include
    ../../../../../common/hdr/cmsis/include/: cmsis_compiler.h core_cm7.h
  group hdr/rev_b
    ../../../../hdr/rev_b/: bb_bsp_tviibh8m.h cy_device_headers.h cyt4bf_config.h
  group hdr/rev_b/ip
    ../../../../hdr/rev_b/ip/: cyip_backup_v3.h cyip_canfd.h cyip_cpuss.h cyip_crypto.h cyip_dmac.h cyip_dw.h cyip_efuse_data_v2.h cyip_efuse_v2.h cyip_eth.h cyip_evtgen.h cyip_fault.h cyip_flashc.h cyip_flexray.h cyip_gpio_v3.h cyip_headers.h cyip_hsiom_v3.h cyip_i2s_v2.h cyip_ipc.h cyip_lin.h cyip_pass.h cyip_peri_ms_v3.h cyip_peri_pclk_v3.h cyip_peri_v3.h cyip_prot.h cyip_scb_v2.h cyip_sdhc.h cyip_sflash_v2.h cyip_smartio_v3.h cyip_smif_v2.h cyip_srss_v3.h cyip_tcpwm_v2.h
  group hdr/rev_c
    ../../../../hdr/rev_c/: bb_bsp_tviibh8m.h cy_device_headers.h cyt4bf_config.h
  group hdr/rev_c/ip
    ../../../../hdr/rev_c/ip/: cyip_backup_v3.h cyip_canfd.h cyip_cpuss.h cyip_crypto.h cyip_dmac.h cyip_dw.h cyip_efuse_data_v2.h cyip_efuse_v2.h cyip_eth.h cyip_evtgen.h cyip_fault.h cyip_flashc.h cyip_flexray.h cyip_gpio_v3.h cyip_headers.h cyip_hsiom_v3.h cyip_i2s_v2.h cyip_ipc.h cyip_lin.h cyip_pass.h cyip_peri_ms_v3.h cyip_peri_pclk_v3.h cyip_peri_v3.h cyip_prot.h cyip_scb_v2.h cyip_sdhc.h cyip_sflash_v2.h cyip_smartio_v3.h cyip_smif_v2.h cyip_srss_v3.h cyip_tcpwm_v2.h
  group hdr/rev_d
    ../../../../hdr/rev_d/: bb_bsp_tviibh8m.h cy_device_headers.h cyt4bf_config.h
  group hdr/rev_d/ip
    ../../../../hdr/rev_d/ip/: cyip_backup_v3.h cyip_canfd.h cyip_coredefines.h cyip_cpuss.h cyip_crypto.h cyip_dmac.h cyip_dw.h cyip_efuse_data_v2.h cyip_efuse_v2.h cyip_eth.h cyip_evtgen.h cyip_fault.h cyip_flashc.h cyip_flexray.h cyip_gpio_v3.h cyip_headers.h cyip_hsiom_v3.h cyip_i2s_v2.h cyip_ipc.h cyip_lin.h cyip_pass.h cyip_peri_ms_v3.h cyip_peri_pclk_v3.h cyip_peri_v3.h cyip_prot.h cyip_scb_v2.h cyip_sdhc.h cyip_sflash_v2.h cyip_smartio_v3.h cyip_smif_v2.h cyip_srss_v3.h cyip_tcpwm_v2.h
  group hdr/rtos
    ../../../../../common/src/rtos/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group lw_eth_drivers
    ../../../../src/lw_eth_drivers/: lw_eth.c lw_eth.h
  group src
    ../../../../src/: main_cm7_0.c
  group src/drivers/adc
    ../../../../../common/src/drivers/adc/: cy_adc.c cy_adc.h
  group src/drivers/audioss
    ../../../../src/drivers/audioss/: cy_i2s.c cy_i2s.h
  group src/drivers/canfd
    ../../../../../common/src/drivers/canfd/: cy_canfd.c cy_canfd.h
  group src/drivers/cpu
    ../../../../src/drivers/cpu/: cy_cpu.c cy_cpu.h
  group src/drivers/crypto
    ../../../../../common/src/drivers/crypto/: cy_crypto.h cy_crypto_common.h cy_crypto_config.c cy_crypto_config.h cy_crypto_server.h
  group src/drivers/dma
    ../../../../../common/src/drivers/dma/: cy_mdma.c cy_mdma.h cy_pdma.c cy_pdma.h
  group src/drivers/ethernet
    ../../../../src/drivers/ethernet/: cdn_errno.h cdn_stdint.h cedi.h cps_v2.h cy_ethif.c cy_ethif.h edd.c edd_int.h edd_rx.c edd_tx.c emac_regs.h emac_regs_macro.h log.h
  group src/drivers/evtgen
    ../../../../../common/src/drivers/evtgen/: cy_evtgen.c cy_evtgen.h
  group src/drivers/flash
    ../../../../../common/src/drivers/flash/: cy_flash.c cy_flash.h
  group src/drivers/flexray/api
    ../../../../src/drivers/flexray/api/: cy_fr_api_control_service.c cy_fr_api_init.c cy_fr_api_interrupt_service.c cy_fr_api_rx_handler.c cy_fr_api_status_service.c cy_fr_api_time_service.c cy_fr_api_timer_service.c cy_fr_api_tx_handler.c
  group src/drivers/flexray/ccal
    ../../../../src/drivers/flexray/ccal/: cy_fr_ccal_control_service.c cy_fr_ccal_init.c cy_fr_ccal_interrupt_service.c cy_fr_ccal_rx_handler.c cy_fr_ccal_status_service.c cy_fr_ccal_time_service.c cy_fr_ccal_timer_service.c cy_fr_ccal_tx_handler.c
  group src/drivers/gpio
    ../../../../../common/src/drivers/gpio/: cy_gpio.c cy_gpio.h
  group src/drivers/ipc
    ../../../../../common/src/drivers/ipc/: cy_ipc_config.h cy_ipc_drv.c cy_ipc_drv.h cy_ipc_pipe.c cy_ipc_pipe.h cy_ipc_sema.c cy_ipc_sema.h
  group src/drivers/lin
    ../../../../../common/src/drivers/lin/: cy_lin.c cy_lin.h
  group src/drivers/lvd
    ../../../../../common/src/drivers/lvd/: cy_lvd.c cy_lvd.h
  group src/drivers/mcwdt
    ../../../../../common/src/drivers/mcwdt/: cy_mcwdt.c cy_mcwdt.h
  group src/drivers/mpu
    ../../../../../common/src/drivers/mpu/: cy_mpu.c cy_mpu.h
  group src/drivers/prot
    ../../../../../common/src/drivers/prot/: cy_prot.c cy_prot.h
  group src/drivers/scb
    ../../../../../common/src/drivers/scb/: cy_scb_common.c cy_scb_common.h cy_scb_ezi2c.c cy_scb_ezi2c.h cy_scb_i2c.c cy_scb_i2c.h cy_scb_spi.c cy_scb_spi.h cy_scb_uart.c cy_scb_uart.h
  group src/drivers/sd_host
    ../../../../src/drivers/sd_host/: cy_sd_host.c cy_sd_host.h
  group src/drivers/smartio
    ../../../../../common/src/drivers/smartio/: cy_smartio.c cy_smartio.h
  group src/drivers/smif
    ../../../../../common/src/drivers/smif/common/: cy_smif.c cy_smif.h cy_smif_memslot.c cy_smif_memslot.h
    ../../../../../common/src/drivers/smif/ver2/: cy_smif_ver_specific.c cy_smif_ver_specific.h
  group src/drivers/srom
    ../../../../../common/src/drivers/srom/: cy_srom.c cy_srom.h
  group src/drivers/sysclk
    ../../../../src/drivers/sysclk/: cy_sysclk.c cy_sysclk.h
  group src/drivers/sysflt
    ../../../../../common/src/drivers/sysflt/: cy_sysflt.c cy_sysflt.h
    ../../../../src/drivers/sysflt/: cy_sysflt_config.h
  group src/drivers/sysint
    ../../../../../common/src/drivers/sysint/: cy_sysint.c cy_sysint.h
  group src/drivers/syslib
    ../../../../../common/src/drivers/syslib/: cy_syslib.c cy_syslib.h
    ../../../../../common/src/drivers/syslib/iar/: cy_syslib_iar.s
  group src/drivers/syspm
    ../../../../../common/src/drivers/syspm/: cy_syspm.c cy_syspm.h
  group src/drivers/sysreghc
    ../../../../src/drivers/sysreghc/: cy_sysreghc.c cy_sysreghc.h
  group src/drivers/sysreset
    ../../../../../common/src/drivers/sysreset/: cy_sysreset.c cy_sysreset.h
  group src/drivers/sysrtc
    ../../../../../common/src/drivers/sysrtc/: cy_sysrtc.c cy_sysrtc.h
  group src/drivers/systick
    ../../../../../common/src/drivers/systick/: cy_systick.c cy_systick.h
  group src/drivers/syswdt
    ../../../../../common/src/drivers/syswdt/: cy_syswdt.c cy_syswdt.h
  group src/drivers/tcpwm
    ../../../../../common/src/drivers/tcpwm/: cy_tcpwm.c cy_tcpwm.h cy_tcpwm_counter.c cy_tcpwm_counter.h cy_tcpwm_pwm.c cy_tcpwm_pwm.h cy_tcpwm_quaddec.c cy_tcpwm_quaddec.h cy_tcpwm_sr.c cy_tcpwm_sr.h
  group src/drivers/trigmux
    ../../../../../common/src/drivers/trigmux/: cy_trigmux.c cy_trigmux.h
  group src/interrupts/rev_b
    ../../../../src/interrupts/rev_b/: cy_interrupt_map.c cy_interrupt_map_cm7_0.h
  group src/interrupts/rev_c
    ../../../../src/interrupts/rev_c/: cy_interrupt_map.c cy_interrupt_map_cm7_0.h
  group src/interrupts/rev_d
    ../../../../src/interrupts/rev_d/: cy_interrupt_map.c cy_interrupt_map_cm7_0.h
  group src/mw/aic261
    ../../../../../common/src/mw/aic261/: cy_aic261.c cy_aic261.h
  group src/mw/button
    ../../../../../common/src/mw/button/: cy_button.c cy_button.h
  group src/mw/eth_phy
    ../../../../src/mw/eth_phy/: cy_dp83867.c cy_dp83867.h
  group src/mw/flash
    ../../../../../common/src/mw/flash/: cy_mw_flash.c cy_mw_flash.h
  group src/mw/power
    ../../../../src/mw/power/: cy_power.c cy_power.h
  group src/mw/semihosting
    ../../../../../common/src/mw/semihosting/: cy_semihosting.c cy_semihosting.h
  group src/mw/smif_mem
    ../../../../src/mw/smif_mem/: cy_smif_device_common.c cy_smif_device_common.h cy_smif_hb_flash.c cy_smif_hb_flash.h cy_smif_s25fl.c cy_smif_s25fl.h cy_smif_s25fs.c cy_smif_s25fs.h cy_smif_semp.c cy_smif_semp.h
  group src/mw/sw_timer
    ../../../../../common/src/mw/sw_timer/: cy_sw_tmr.c cy_sw_tmr.h
  group src/rtos
    ../../../../../common/src/rtos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group src/rtos/mem_mgmt
    ../../../../../common/src/rtos/portable/MemMang/: heap_4.c
  group src/rtos/portable
    ../../../../../common/src/rtos/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s portmacro.h
  group src/startup
    ../../../../../common/src/startup/: startup.c startup_customize.h
    ../../../../../common/src/startup/iar/: startup_cm7.s
  group src/system/rev_b
    ../../../../src/system/rev_b/: system_cyt4bf.h system_tviibh8m_cm7.c
  group src/system/rev_c
    ../../../../src/system/rev_c/: system_cyt4bf.h system_tviibh8m_cm7.c
  group src/system/rev_d
    ../../../../src/system/rev_d/: system_cyt4bf.h system_tviibh8m_cm7.c
